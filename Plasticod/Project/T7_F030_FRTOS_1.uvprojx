# Keil uVision project T7_F030_FRTOS_1.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: T7_F030_FRTOS_1 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F0XX,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\Include;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM0;..\STM32F0xx_StdPeriph_Driver\inc;..\USER;..\CMSIS;..\hal;..\MyLib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../CMSIS/Source/Templates/arm/: startup_stm32f030.s
  group STM32F0xx_StdPeriph_Driver
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_syscfg.c stm32f0xx_misc.c
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c timers.c tasks.c
    ../FreeRTOS/portable/RVDS/ARM_CM0/: port.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
  group USER
    ../USER/: main.c usart.c system_stm32f0xx.c stm32f0xx_it.c
    ../MyLib/: LoopBuf.c
  group Hal
    ../hal/: HD_PLASTIC1_F0.C
    ../HAL_Free/: uart_FREE.c
