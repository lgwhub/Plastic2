# Keil uVision project Mode1.uvproj, settings and files
target STM32F103_Mode (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Const10 +hex
  AfterMake: CopyHex.bat
  c flags: Optim=1 OneElfS=1
  c include: ..\STM32F1xx_StdPeriph_Driver\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\STM32F1xx_StdPeriph_Driver\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src;..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\inc;..\STM32F1xx_StdPeriph_Driver\CMSIS\CM3\CoreSupport;..\HAL;..\HAL_ucOS;..\MyLib;..\app;..\USER_ucOS;..\ucOS;..\ucOS\uC-CPU;..\ucOS\uCOS-II;..\ucOS\uCOS-VIEW;..\ucOS\uC-LIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../STM32F1xx_StdPeriph_Driver/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group User
    ../USER_ucOS/: stm32f10x_it.c uctsk_OSView.c main.c user.c Sof_ucOS.c
    ../app/: PID.c Lcd.c app1.c
  group Hal
    ../HAL_ucOS/: uart_UCOS.c jump3.c pwm1.c adc.c SPI1.C HT1621.c
    ../hal/: HD_PLASTIC1_F1.C
  group mylib
    ../MyLib/: GetAverage.c looplib.lib NOMAL.c ClearErrSample.c
  group StdPeriph_Driver
    ../STM32F1xx_StdPeriph_Driver/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../STM32F1xx_StdPeriph_Driver/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER_ucOS/: system_stm32f10x.c
  group uC-OS-II/Port
    ../ucOS/uCOS-II/Ports/ARM-Cortex-M3/RealView/: os_dbg.c os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC-OS-II/Source
    ../ucOS/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Config
    ../USER_ucOS/: OS_AppHooks.c
  group uC-OS-II/CPU
    ../ucOS/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm cpu.h
    ../ucOS/uC-CPU/: cpu_def.h
  group uC-OS-II/LIB/Source
    ../ucOS/uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC-OS-II/LIB/Port
    ../ucOS/uC-LIB/Ports/RealView/: lib_mem_a.asm
  group uC-OS-II/VIEW/Source
    ../ucOS/uCOS-VIEW/Source/: os_view.c os_view.h
  group uC-OS-II/VIEW/Port
    ../ucOS/uCOS-VIEW/Ports/ARM-Cortex-M3/Realview/: os_viewc.h os_viewc.c
