### uVision2 Project, (C) Keil Software
### Do not modify !

Target (STM32F103_Mode), 0x0004 // Tools: 'ARM-ADS'

Group (Startup)
Group (User)
Group (Hal)
Group (mylib)
Group (StdPeriph_Driver)
Group (CMSIS)
Group (uC-OS-II/Port)
Group (uC-OS-II/Source)
Group (uC-OS-II/Config)
Group (uC-OS-II/CPU)
Group (uC-OS-II/LIB/Source)
Group (uC-OS-II/LIB/Port)
Group (uC-OS-II/VIEW/Source)
Group (uC-OS-II/VIEW/Port)

File 1,2,<..\STM32F1xx_StdPeriph_Driver\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm\startup_stm32f10x_hd.s><startup_stm32f10x_hd.s>
File 2,4,<..\MyLib\ClearErrSample.lib><ClearErrSample.lib>
File 2,1,<..\USER_ucOS\stm32f10x_it.c><stm32f10x_it.c>
File 2,1,<..\USER_ucOS\uctsk_OSView.c><uctsk_OSView.c>
File 2,1,<..\USER_ucOS\main.c><main.c>
File 2,1,<..\USER_ucOS\user.c><user.c>
File 2,1,<..\USER_ucOS\Sof_ucOS.c><Sof_ucOS.c>
File 2,1,<..\app\Lcd.c><Lcd.c>
File 2,1,<..\app\app1.c><app1.c>
File 3,1,<..\HAL_ucOS\uart_UCOS.c><uart_UCOS.c>
File 3,1,<..\hal\HD_PLASTIC1_F1.C><HD_PLASTIC1_F1.C>
File 3,1,<..\HAL_ucOS\jump3.c><jump3.c>
File 3,1,<..\HAL_ucOS\pwm1.c><pwm1.c>
File 3,1,<..\HAL_ucOS\adc.c><adc.c>
File 3,1,<..\HAL_ucOS\SPI1.C><SPI1.C>
File 3,1,<..\HAL_ucOS\HT1621.c><HT1621.c>
File 4,1,<..\MyLib\GetAverage.c><GetAverage.c>
File 4,4,<..\MyLib\looplib.lib><looplib.lib>
File 4,1,<..\MyLib\NOMAL.c><NOMAL.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\misc.c><misc.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_adc.c><stm32f10x_adc.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_bkp.c><stm32f10x_bkp.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_can.c><stm32f10x_can.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_cec.c><stm32f10x_cec.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_crc.c><stm32f10x_crc.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_dac.c><stm32f10x_dac.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_dbgmcu.c><stm32f10x_dbgmcu.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_dma.c><stm32f10x_dma.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_exti.c><stm32f10x_exti.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_flash.c><stm32f10x_flash.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_fsmc.c><stm32f10x_fsmc.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_gpio.c><stm32f10x_gpio.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_i2c.c><stm32f10x_i2c.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_iwdg.c><stm32f10x_iwdg.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_pwr.c><stm32f10x_pwr.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_rcc.c><stm32f10x_rcc.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_rtc.c><stm32f10x_rtc.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_sdio.c><stm32f10x_sdio.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_spi.c><stm32f10x_spi.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_tim.c><stm32f10x_tim.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_usart.c><stm32f10x_usart.c>
File 5,1,<..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src\stm32f10x_wwdg.c><stm32f10x_wwdg.c>
File 6,1,<..\STM32F1xx_StdPeriph_Driver\CMSIS\CM3\CoreSupport\core_cm3.c><core_cm3.c>
File 6,1,<..\USER_ucOS\system_stm32f10x.c><system_stm32f10x.c>
File 7,1,<..\ucOS\uCOS-II\Ports\ARM-Cortex-M3\RealView\os_dbg.c><os_dbg.c>
File 7,5,<..\ucOS\uCOS-II\Ports\ARM-Cortex-M3\RealView\os_cpu.h><os_cpu.h>
File 7,2,<..\ucOS\uCOS-II\Ports\ARM-Cortex-M3\RealView\os_cpu_a.asm><os_cpu_a.asm>
File 7,1,<..\ucOS\uCOS-II\Ports\ARM-Cortex-M3\RealView\os_cpu_c.c><os_cpu_c.c>
File 8,1,<..\ucOS\uCOS-II\Source\os_core.c><os_core.c>
File 8,1,<..\ucOS\uCOS-II\Source\os_flag.c><os_flag.c>
File 8,1,<..\ucOS\uCOS-II\Source\os_mbox.c><os_mbox.c>
File 8,1,<..\ucOS\uCOS-II\Source\os_mem.c><os_mem.c>
File 8,1,<..\ucOS\uCOS-II\Source\os_mutex.c><os_mutex.c>
File 8,1,<..\ucOS\uCOS-II\Source\os_q.c><os_q.c>
File 8,1,<..\ucOS\uCOS-II\Source\os_sem.c><os_sem.c>
File 8,1,<..\ucOS\uCOS-II\Source\os_task.c><os_task.c>
File 8,1,<..\ucOS\uCOS-II\Source\os_time.c><os_time.c>
File 8,1,<..\ucOS\uCOS-II\Source\os_tmr.c><os_tmr.c>
File 9,1,<..\USER_ucOS\OS_AppHooks.c><OS_AppHooks.c>
File 10,1,<..\ucOS\uC-CPU\ARM-Cortex-M3\RealView\cpu_c.c><cpu_c.c>
File 10,5,<..\ucOS\uC-CPU\cpu_def.h><cpu_def.h>
File 10,2,<..\ucOS\uC-CPU\ARM-Cortex-M3\RealView\cpu_a.asm><cpu_a.asm>
File 10,5,<..\ucOS\uC-CPU\ARM-Cortex-M3\RealView\cpu.h><cpu.h>
File 11,5,<..\ucOS\uC-LIB\lib_def.h><lib_def.h>
File 11,1,<..\ucOS\uC-LIB\lib_mem.c><lib_mem.c>
File 11,5,<..\ucOS\uC-LIB\lib_mem.h><lib_mem.h>
File 11,1,<..\ucOS\uC-LIB\lib_str.c><lib_str.c>
File 11,5,<..\ucOS\uC-LIB\lib_str.h><lib_str.h>
File 12,2,<..\ucOS\uC-LIB\Ports\RealView\lib_mem_a.asm><lib_mem_a.asm>
File 13,1,<..\ucOS\uCOS-VIEW\Source\os_view.c><os_view.c>
File 13,5,<..\ucOS\uCOS-VIEW\Source\os_view.h><os_view.h>
File 14,5,<..\ucOS\uCOS-VIEW\Ports\ARM-Cortex-M3\Realview\os_viewc.h><os_viewc.h>
File 14,1,<..\ucOS\uCOS-VIEW\Ports\ARM-Cortex-M3\Realview\os_viewc.c><os_viewc.c>


Options 1,0,0  // Target 'STM32F103_Mode'
 Device (STM32F103VE)
 Vendor (STMicroelectronics)
 Cpu (IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3"))
 FlashUt ()
 StupF ("STARTUP\ST\STM32F10x.s" ("STM32 Startup Code"))
 FlashDR (UL2CM3(-O14 -S0 -C0 -N00("ARM Cortex-M3") -D00(1BA00477) -L00(4) -FO7 -FD20000000 -FC800 -FN1 -FF0STM32F10x_512 -FS08000000 -FL080000))
 DevID (4225)
 Rgf (stm32f10x_lib.h)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg (ST\STM32F10x\)
 OrgReg (ST\STM32F10x\)
 TgStat=16
 OutDir (.\Obj\)
 OutName (Const10)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=1
 LstDir (.\List\)
 HexSel=1
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 CrunUsr 0 0 <>
 CrunUsr 1 0 <>
 SVCSID <>
 GLFLAGS=1790
 ADSFLGA { 243,31,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ACPUTYP ("Cortex-M3")
 RVDEV ()
 ADSTFLGA { 0,12,0,2,163,0,0,66,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMADSOCM { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMADSIRAM { 0,0,0,0,32,0,0,1,0 }
 OCMADSIROM { 1,0,0,0,8,0,0,8,0 }
 OCMADSXRAM { 0,0,0,0,0,0,0,0,0 }
 OCR_RVCT { 1,0,0,0,0,0,0,0,0,1,0,0,0,0,0,0,0,0,1,0,0,0,0,0,0,0,0,1,0,0,0,8,0,0,8,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,32,0,0,1,0,0,0,0,0,0,0,0,0,0 }
 RV_STAVEC ()
 ADSCCFLG { 5,32,8,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSCMISC ()
 ADSCDEFN ()
 ADSCUDEF ()
 ADSCINCD (..\STM32F1xx_StdPeriph_Driver\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\STM32F1xx_StdPeriph_Driver\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\src;..\STM32F1xx_StdPeriph_Driver\STM32F10x_StdPeriph_Driver\inc;..\STM32F1xx_StdPeriph_Driver\CMSIS\CM3\CoreSupport;..\HAL;..\HAL_ucOS;..\MyLib;..\app;..\USER_ucOS;..\ucOS;..\ucOS\uC-CPU;..\ucOS\uCOS-II;..\ucOS\uCOS-VIEW;..\ucOS\uC-LIB)
 ADSASFLG { 1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSAMISC ()
 ADSADEFN ()
 ADSAUDEF ()
 ADSAINCD ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 ADSLDFG { 17,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSLDTA (0x08000000)
 ADSLDDA (0x20000000)
 ADSLDSC ()
 ADSLDIB ()
 ADSLDIC ()
 ADSLDMC ()
 ADSLDIF ()
 ADSLDDW ()
  OPTDL (SARMCM3.DLL)()(DARMSTM.DLL)(-pSTM32F103VE)(SARMCM3.DLL)()(TARMSTM.DLL)(-pSTM32F103VE)
  OPTDBG 49150,13,()()()()()()()()()() (STLink\ST-LINKIII-KEIL_SWO.dll)()()()
 FLASH1 { 25,0,0,0,1,0,0,0,8,16,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 (STLink\ST-LINKIII-KEIL_SWO.dll)
 FLASH3 ("" ())
 FLASH4 ()
EndOpt

